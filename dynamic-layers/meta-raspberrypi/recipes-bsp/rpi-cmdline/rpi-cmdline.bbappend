DISABLE_SPLASH = "1"
DISABLE_RPI_BOOT_LOGO = "1"
CMDLINE += "\
    consoleblank=1 \
    loglevel=0 \
    "
