FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI += " \
    file://0001_boot_time_optimiziation_path.patch \
    "
