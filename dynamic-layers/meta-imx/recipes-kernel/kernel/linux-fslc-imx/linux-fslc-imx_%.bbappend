FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI += " \
    file://0001_dt_path.patch \
    "
