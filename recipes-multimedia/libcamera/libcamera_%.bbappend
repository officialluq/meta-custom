PACKAGECONFIG += " gst"