PACKAGECONFIG[libmpv] = " --enable-libmpv-shared"
PACKAGECONFIG:append = " libmpv"
